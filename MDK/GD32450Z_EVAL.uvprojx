# Keil uVision project GD32450Z_EVAL.uvprojx, settings and files
target GD32F427ZKT6_APP (ARM-ADS)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LaiSi_APP +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,_IAP_APP_USED_,__916_BOARD__
  c include: ..\MDK;.\Library\Firmware\GD32F4xx_standard_peripheral\Include;.\Library\Utilities;.\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include;.\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Library\Firmware\CMSIS\GD\GD32F4xx\Include;.\Library\Firmware\CMSIS;..\;.\inc;.\Third_Party\lwip-2.1.2\src\include;.\Third_Party\lwip-2.1.2\src\include\lwip;.\Third_Party\lwip-2.1.2\src\include\netif;.\Third_Party\lwip-2.1.2\src\include\compat;.\Third_Party\lwip-2.1.2\port\GD32F4xx;.\Third_Party\lwip-2.1.2\port\GD32F4xx\FreeRTOS;.\inc\comm;.\inc\wdg;.\app\ipmb;.\inc\ymodem;.\inc\ymodem;.\inc\hk_sensor;.\inc\adc;.\inc;.\inc\online_check
  asm include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/console/: Sample-CLI-commands.c serial.c UARTCommandConsole.c
    ./app/fmc/: fmc.c
    ./app/spi/: gd25qxx.c
    ./app/comm/: basecpld.c
    ./app/upgrade/: bootload.c biosupgrade.c bmcupgrade.c
    ./app/syswarn/: hk_sys_warn.c
    ./app/i2c/: hk_i2c.c
    ./app/: pin.c
    ./app/emmc/: emmc.c
    ./app/ipmb/: ipmb.c ipmb_slave.c
    ./app/fatfs/: diskio.c fatfs_user.c ff.c
    ./app/wdg/: hk_wdg.c
    ./app/ymodem/: common.c download.c ymodem.c hk_common.c hk_ymodem.c
    ./app/hk_sensor/: hk_sensor.c
    ./app/adc/: hk_adc.c
    ./app/online_check/: online_check.c
  group main
    ../: gd32f4xx_it.c main.c systick.c
  group FreeRTOS
    ./Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOS_CLI.c
    ./Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GD32F4xx_EVAL
    ./Library/Utilities/: gd32f450z_eval.c
  group GD32F4xx_Peripherals
    ./Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ./Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Startup
    ./Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
target GD32F427ZKT6_BOOT (ARM-ADS)
  device: GD32F427ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: GD32450Z_BOOT +hex
  AfterMake: fromelf.exe --bin -o boot.bin ./output/boot/GD32450Z_BOOT.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427,_IAP_BOOT_USED_,__916_BOARD__
  c include: ..\MDK;.\Library\Firmware\GD32F4xx_standard_peripheral\Include;.\Library\Utilities;.\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include;.\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;.\Library\Firmware\CMSIS\GD\GD32F4xx\Include;.\Library\Firmware\CMSIS;..\;.\inc;.\Third_Party\lwip-2.1.2\src\include;.\Third_Party\lwip-2.1.2\src\include\lwip;.\Third_Party\lwip-2.1.2\src\include\netif;.\Third_Party\lwip-2.1.2\src\include\compat;.\Third_Party\lwip-2.1.2\port\GD32F4xx;.\Third_Party\lwip-2.1.2\port\GD32F4xx\FreeRTOS;.\app\ymodem;.\app\comm;.\inc\ymodem;.\inc\comm;.\inc\hk_sensor;.\inc\online_check
  asm include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
